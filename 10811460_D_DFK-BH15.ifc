Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2020-10-15T11:55:42
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170419_0315(x64) - Exporter 17.0.1128.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 15 11:55:42 2020 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{97A51462-D746-4DC3-BA27-7CACBA251893}\ifc * Database version: 5507 * Database creation date: Thu Oct 15 11:55:40 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 15 11:55:41 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 15 11:55:41 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 28996395_D_10811460_DFK-BH15, 10811460_D_DFK-BH15:28996395_D_10811460_DFK-BH15:202202
In: Level 1
Type - Material: z_Miele_Plastic_Signal_White
Pset_BuildingElementProxyCommon - Reference: 28996395_D_10811460_DFK-BH15
